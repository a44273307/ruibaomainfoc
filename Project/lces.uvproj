# Keil uVision project lces.uvproj, settings and files
target Project (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: lces +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\User;..\Library
  group System
    ./: STARTUP.A51
  group User
    ../User/: delay.c main.c uart.c
